# Keil uVision project gpio.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: MK22FN512VLH12 NXP
  pack: NXP.MK22F51212_DFP.13.0.0
  cpu: IRAM(0x1fff0000,0x010000) IRAM2(0x20000000,0x010000) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gpio
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK22FN512VLH12, FRDM_K22F, FREEDOM
  c misc: -fdata-sections -ffreestanding -fno-builtin -mthumb
  asm define: DEBUG
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\RTE\Device\MK22FN512VLH12\MK22FN512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group driverlib
    ./: gpio.c
software components: CMSIS:CORE 5.4.0, Device:CMSIS:MK22F51212_header 1.0.0, Device:CMSIS:MK22F51212_system 1.0.0, Device:Startup:MK22F51212_startup 1.1.0
